# Keil uVision project AT32F456CEU7_foc.uvprojx, settings and files
target AT32F456CEU7_foc (6190000::V6.19::ARMCLANG)
  device: AT32F456CEU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F456CEU7_foc +hex
  AfterMake: fromelf --bin -o ".\bin_file\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F456CEU7, USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\Core\Inc;..\foc\foc_fast;..\foc\foc_app;
  memory RVCT4: ROM 0x8004000 size 0x3b800
  memory RVCT9: RAM 0x20000000 size 0x24000
  group user
    ../src/: at32f45x_int.c at32f45x_wk_config.c main.c wk_system.c wk_adc.c wk_can.c wk_tmr.c wk_usart.c wk_gpio.c wk_dma.c flash_port.c
  group firmware
    ../../libraries/drivers/src/: at32f45x_crm.c at32f45x_tmr.c at32f45x_gpio.c at32f45x_usart.c at32f45x_pwc.c at32f45x_adc.c at32f45x_dma.c at32f45x_debug.c at32f45x_flash.c at32f45x_misc.c at32f45x_scfg.c at32f45x_can.c
  group cmsis
    ./: startup_at32f45x.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
  group foc_fast
    ../foc/foc_fast/: encoder_calc.c foc_api.c foc_bsp.c foc_controller.c foc_current_loop.c foc_data.c foc_kernel.c foc_position_loop.c foc_speed_loop.c foc_test.c func_errMes.c func_filter.c func_pid.c func_subprogram.c func_trigonometric.c sei.c
  group foc_app
    ../foc/foc_app/: ifly_fault.c ifly_fault_api.c ifly_flux_ident.c ifly_inertia_ident.c ifly_led.c ifly_test.c phase_resistance_ident.c can_wly.c can_debug.c
    ../src/: ota_app.c
