# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (6050000::V6.5::.\ARMCLANG)
  device: AT32F456CEU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F456CEU7
  c include: ..\..\libraries\cmsis\cm4\core_support;..\..\libraries\drivers\inc;..\inc;..\..\libraries\cmsis\cm4\device_support
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x24000
  link misc: --scatter=.\bootloader.sct
  group Startup
    ../system/: startup_at32f45x.s
  group CMSIS
    ../system/: system_at32f45x.c
  group BSP
    ../../libraries/drivers/src/: at32f45x_crm.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_usart.c at32f45x_pwc.c
  group Bootloader
    ../src/: flash.c main.c boot_usart.c
    ../system/: at32f45x_int.c
