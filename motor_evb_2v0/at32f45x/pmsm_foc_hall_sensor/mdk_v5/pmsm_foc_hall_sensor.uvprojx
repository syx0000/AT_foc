# Keil uVision project pmsm_foc_hall_sensor.uvprojx, settings and files
target demo (6240000::V6.24::ARMCLANG)
  device: AT32F456CEU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pmsm_foc_hall_sensor +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F456CEU7,USE_STDPERIPH_DRIVER,ARM_DSP_CONFIG_TABLES,ARM_FAST_ALLOW_TABLES,ARM_TABLE_SIN_Q15
  c include: ..\..\..\..\mclib\inc;..\inc;..\..\..\..\libraries\AT32F45x_Firmware_Library\drivers\inc;..\..\..\..\libraries\AT32F45x_Firmware_Library\cmsis\cm4\core_support;..\..\..\..\libraries\AT32F45x_Firmware_Library\cmsis\cm4\device_support
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7f800
  memory RVCT5: ROM 0x807f800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x24000
  group user
    ../src/: at32f45x_clock.c at32f45x_int.c main.c mc_hwio.c mc_isr.c mc_ident_diag.c mc_can_motor.c
    ../inc/: mc_hwio_v2.h mc_lib.h mc_ident_diag.h motor_control_drive_param.h
  group firmware
    ../../../../libraries/AT32F45x_Firmware_Library/drivers/src/: at32f45x_acc.c at32f45x_adc.c at32f45x_aes.c at32f45x_can.c at32f45x_crc.c at32f45x_crm.c at32f45x_dac.c at32f45x_debug.c at32f45x_dma.c at32f45x_emac.c at32f45x_ertc.c at32f45x_exint.c at32f45x_flash.c at32f45x_gpio.c at32f45x_i2c.c at32f45x_misc.c at32f45x_pwc.c at32f45x_qspi.c at32f45x_scfg.c at32f45x_sdio.c at32f45x_spi.c at32f45x_tmr.c at32f45x_trng.c at32f45x_usart.c at32f45x_usb.c at32f45x_wdt.c at32f45x_wwdt.c at32f45x_xmc.c
  group cmsis
    ../../../../libraries/AT32F45x_Firmware_Library/cmsis/cm4/device_support/: system_at32f45x.c
    ../../../../libraries/AT32F45x_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
  group cmsis_dsp
    ../../../../libraries/dsp/Source/CommonTables/: CommonTables.c
    ../../../../libraries/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../../../libraries/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../libraries/dsp/Source/InterpolationFunctions/: InterpolationFunctions.c
  group mclib
    ../../../../mclib/src/: mc_delay.c mc_foc.c mc_curr_fdbk.c mc_encoder.c mc_pid_controller.c mc_foc_globals.c mc_math.c mc_field_weakening.c mc_hall.c mc_foc_sensorless.c mc_comm_uart.c user_interface_foc.c motor_control_foc.c mc_flash_data_table_foc.c mc_curr_decoupling.c mc_foc_esc_state_hall.c mc_foc_kernal.lib
  group readme
    ../: readme.txt
