# IAR project pmsm_foc_hall_sensor.ewp, settings and files
configuration demo (ARM, debug)
  General.OGChipSelectEditMenu: AT32F455RET7_v2 ArteryTek AT32F455RET7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F455RET7; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../../../../mclib/inc; ../inc; ../../../../libraries/AT32F45x_Firmware_Library/drivers/inc; ../../../../libraries/AT32F45x_Firmware_Library/cmsis/cm4/core_support; ../../../../libraries/AT32F45x_Firmware_Library/cmsis/cm4/device_support
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: AT32F455xE_mcdata.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ../../../../libraries/AT32F45x_Firmware_Library/cmsis/cm4/device_support/startup/iar/: startup_at32f45x.s
    ../../../../libraries/AT32F45x_Firmware_Library/cmsis/cm4/device_support/: system_at32f45x.c
  group cmsis_dsp
    ../../../../libraries/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../libraries/dsp/Source/CommonTables/: CommonTables.c
    ../../../../libraries/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../../../libraries/dsp/Source/InterpolationFunctions/: InterpolationFunctions.c
  group firmware
    ../../../../libraries/AT32F45x_Firmware_Library/drivers/src/: at32f45x_acc.c at32f45x_adc.c at32f45x_aes.c at32f45x_can.c at32f45x_crc.c at32f45x_crm.c at32f45x_dac.c at32f45x_debug.c at32f45x_dma.c at32f45x_emac.c at32f45x_ertc.c at32f45x_exint.c at32f45x_flash.c at32f45x_gpio.c at32f45x_i2c.c at32f45x_misc.c at32f45x_pwc.c at32f45x_qspi.c at32f45x_scfg.c at32f45x_sdio.c at32f45x_spi.c at32f45x_tmr.c at32f45x_trng.c at32f45x_usart.c at32f45x_usb.c at32f45x_wdt.c at32f45x_wwdt.c at32f45x_xmc.c
  group mclib
    ../../../../mclib/src/: mc_comm_uart.c mc_curr_decoupling.c mc_curr_fdbk.c mc_delay.c mc_encoder.c mc_field_weakening.c mc_flash_data_table_foc.c mc_foc.c mc_foc_esc_state_hall.c mc_foc_globals.c mc_foc_kernal.a mc_foc_sensorless.c mc_hall.c mc_math.c mc_pid_controller.c motor_control_foc.c user_interface_foc.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f45x_clock.c at32f45x_int.c main.c mc_hwio.c mc_isr.c
    ../inc/: mc_hwio_v2.h mc_lib.h motor_control_drive_param.h
